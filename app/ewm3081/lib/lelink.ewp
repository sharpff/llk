# IAR project lelink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lelink.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG; PF_VAL=6; __LE_SDK__; EWM3801
  ICCARM.CCDiagSuppress: Pe223,Pa050,Pe001,Pe826,Pe381,Pe177,Pe144
  ICCARM.CCIncludePath2: ..\..\..\sw; ..\..\..\sw\crypto; ..\..\..\sw\jsmn; ..\..\..\sw\mbedtls-2.2.0_crypto\include; ..\..\..\sw\mbedtls-2.2.0_crypto\include\mbedtls; ..\..\..\sw\mbedtls-2.2.0_crypto\library; ..\..\..\sw\sengine
  ICCARM.CCOptLevel: 0
  group sw
    ../../../sw/: airconfig.c airconfig.h cache.c cache.h convertor.c convertor.h data.c data.h header.h io.c io.h leconfig.h misc.c misc.h network.c network.h ota.c ota.h pack.c pack.h protocol.c protocol.h sengine.c sengine.h state.c state.h utility.c utility.h version.h
  group sw/crypto
    ../../../sw/crypto/: aesWrapper.c aesWrapper.h md5Wrapper.c md5Wrapper.h rsaWrapper.c rsaWrapper.h
  group sw/jsmn
    ../../../sw/jsmn/: jsgen.c jsgen.h jsmn-priv.h jsmn.c jsonv2.h jswrap.c
  group sw/mbedtls-2.2.0_crypto/include/mbedtls
    ../../../sw/mbedtls-2.2.0_crypto/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group sw/mbedtls-2.2.0_crypto/library
    ../../../sw/mbedtls-2.2.0_crypto/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group sw/sengine
    ../../../sw/sengine/: fpconv.c fpconv.h lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lbitlib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c llex.c llex.h llimits.h lmem.c lmem.h lobject.c lobject.h lopcodes.c lopcodes.h lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltm.c ltm.h lua.h lua_cjson.c lua_clib.c lua_clib.h luaconf.h lualib.h lundump.c lundump.h lvm.c lvm.h lzio.c lzio.h strbuf.c strbuf.h
